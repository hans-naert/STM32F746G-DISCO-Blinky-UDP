# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit
  group Source Files
    ./: main.c Blinky.c stdout_USART.c
  group Documentation
    ./: Abstract.txt
target Release (6180000::V6.18::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit --diag_suppress=L6314
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.18.0, Network:Interface:ETH 7.18.0, Network:Socket:BSD 7.18.0, Network:Socket:TCP 7.18.0, Network:Socket:UDP 7.18.0, Board Support:Buttons 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:USART 1.21.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5
